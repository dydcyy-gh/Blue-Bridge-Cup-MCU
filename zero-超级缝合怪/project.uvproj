# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: p0init.c BeepRelay.c led.c shuma.c 4key.c 16key.c timer1.c uart1timer2.c iic.c at24c02.c pcf8591.c onewire.c pwmtimer2.c ds1302.c timer0.c wave.c typedef.h ds18b20.c
