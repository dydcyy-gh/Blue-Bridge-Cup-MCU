# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 16key.c 16key.h BeepRelay.c BeepRelay.h led.c led.h main.c p0init.c p0init.h shuma.c shuma.h timer1.c timer1.h typedef.h
